require python-pycryptodomex.inc
inherit setuptools

require u-boot-common-optee.inc
require u-boot.inc

DEPENDS += "bc-native dtc-native"
